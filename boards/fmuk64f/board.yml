## boards/fmuk64f/board.yml
```yaml
board:
  name: fmuk64f
  full_name: FMUK64F
  vendor: nxp
  socs:
    - name: mk64f12
```
